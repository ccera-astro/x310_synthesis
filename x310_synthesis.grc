options:
  parameters:
    author: Marcus Leech, http://www.ccera.ca
    description: A 4-channel correlator for aperture synthesis in radio astronomy
    generate_options: no_gui
    id: x310_synthesis
    output_language: python
    run_options: run
    title: X310 multi correlator
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: int(srate)
  states: {}
- name: a1enu
  id: parameter
  parameters:
    label: Antenna 1 ENU
    type: str
    value: '"(0.8,0.0,0.0)"'
  states: {}
- name: a2enu
  id: parameter
  parameters:
    label: ANtenna 2 ENU
    type: str
    value: '"(5.35,0.0,0.0)"'
  states: {}
- name: a3enu
  id: parameter
  parameters:
    label: Antenna 3 ENU
    type: str
    value: '"(18.35,0.0,0.0)"'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate)
    type: complex
    vlen: '6'
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0_0_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0_0_0_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '6'
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
    vlen: '6'
  states: {}
- name: device
  id: parameter
  parameters:
    label: Device string
    type: str
    value: '"type=x300,addr=192.168.10.5,master_clock_rate=200e6"'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Frequency
    type: eng_float
    value: 1417.0e6
  states: {}
- name: fringe_logger
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pymap3d as pm
      import time
      import json
      import ephem


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, veclen=6, medlen=5, refWGS84=(0,0,0), a1enu=(0,0,0), a2enu=(0,0,0), a3enu=(0,0,0), pairings=(), prefix="./", declination=-99.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Filter and Logger for fringes',   # will show up in GRC
                  in_sig=[(np.complex64,veclen)],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.veclen = veclen
              self.medlen = medlen
              self.set_output_multiple(self.medlen)
              self.pairings = pairings
              self.medianI = np.zeros((self.veclen, self.medlen))
              self.medianQ = np.zeros((self.veclen, self.medlen))

              self.prefix = prefix
              self.refWGS84 = refWGS84
              enus=[(0,0,0),a1enu,a2enu,a3enu]
              xyzs = []
              for enu in enus:
                  xyzs.append(pm.ecef.enu2ecef(enu[0], enu[1], enu[2], refWGS84[0], refWGS84[1],
                      refWGS84[2]))
              pdict = {}
              pdict["declination"] = declination
              
              #
              # Create the baselines array from the given pairings input
              #
              # The baseline tuples are always (WESTxyz,EASTxyz)
              #
              baselines = []
              for p in pairings:
                  one = xyzs[p[0]]
                  two = xyzs[p[1]]
                  baselines.append([one,two])

              pdict["refWGS84"] = refWGS84
              pdict["refXYZ"] = pm.ecef.enu2ecef(0.0, 0.0, 0.0, refWGS84[0], refWGS84[1], refWGS84[2])
              pdict["baselinesXYZ"] = baselines
              ltp = time.gmtime()
              fn = prefix+"corr-%04d%02d%02d.json" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday)
              fp = open(fn, "w")
              fp.write (json.dumps(pdict, indent=4)+"\n")
              fp.close()
          
          def cur_sidereal(self,longitude):
              longstr = "%02d" % int(longitude)
              longstr = longstr + ":"
              longitude = abs(longitude)
              frac = longitude - int(longitude)
              frac *= 60
              mins = int(frac)
              longstr += "%02d" % mins
              longstr += ":00"
              x = ephem.Observer()
              x.date = ephem.now()
              x.long = longstr
              jdate = ephem.julian_date(x)
              tokens=str(x.sidereal_time()).split(":")
              hours=int(tokens[0])
              minutes=int(tokens[1])
              seconds=int(float(tokens[2]))
              sidt = "%02d,%02d,%02d" % (hours, minutes, seconds)
              return (sidt)       

          def work(self, input_items, output_items):
              medcount = 0
              #
              # For each input item--guaranteed to be multiple of self.medlen
              #
              for itm in input_items[0]:
                  #
                  # Stuff appropriate slot in self.medianI/Q
                  #
                  for i in range(0,len(itm)):
                      self.medianI[i][medcount] = itm[i].real
                      self.medianQ[i][medcount] = itm[i].imag
                  
                  #
                  # Bump the counter
                  #
                  medcount += 1
                  
                  #
                  # Time to log!
                  #
                  if (medcount >= self.medlen):
                      medcount = 0
                      ltp = time.gmtime()
                      fn = "corr-%04d%02d%02d.csv" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday)
                      curs = self.cur_sidereal(self.refWGS84[1])
                      fp = open(self.prefix+fn, "a")
                      fp.write("%s," % curs)
                      for i in range(0,len(itm)):
                          fp.write("%.6f:%.6f" % (np.median(self.medianI[i]), np.median(self.medianQ[i])))
                          if (i < len(itm)-1):
                              fp.write(",")
                      fp.write("\n")
                      fp.close()
        
              return len(input_items[0])
    a1enu: eval(a1enu)
    a2enu: eval(a2enu)
    a3enu: eval(a3enu)
    declination: '-99.0'
    medlen: '5'
    pairings: ((0,1),(0,2),(0,3),(1,2),(1,3),(2,3))
    prefix: '"./"'
    refWGS84: eval(refpos)
    veclen: '6'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      For N antennas with unique spacings,
      there are N(N-1)/2
      Possible unique baselines
  states: {}
- name: refpos
  id: parameter
  parameters:
    label: Reference WGS84 position
    type: str
    value: '"(44.8955,-76.019005,117.0)"'
  states: {}
- name: rfgain
  id: parameter
  parameters:
    label: RF Gain setting
    type: eng_float
    value: '20.0'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0/(samp_rate)
    type: complex
    vlen: '6'
  states: {}
- name: single_pole_iir_filter_xx_1
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0/(2.0*60)
    type: complex
    vlen: '6'
  states: {}
- name: srate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 5.0e6
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX1
    ant1: RX2
    ant2: RX1
    ant3: RX2
    center_freq0: freq
    center_freq1: freq
    center_freq2: freq
    center_freq3: freq
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dc_offs_enb2: '""'
    dc_offs_enb3: '""'
    dev_args: device
    gain0: rfgain
    gain1: rfgain
    gain2: rfgain
    gain3: rfgain
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    iq_imbal_enb2: '""'
    iq_imbal_enb3: '""'
    nchan: '4'
    norm_gain0: 'False'
    norm_gain1: 'False'
    norm_gain2: 'False'
    norm_gain3: 'False'
    otw: sc16
    rx_agc2: Default
    rx_agc3: Default
    samp_rate: samp_rate
    sd_spec0: A:0 A:1 B:0 B:1
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    comment: WEST
    stream_id: rf0
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: rf1
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: rf2
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    comment: EAST
    stream_id: rf3
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: corr_vector
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rf0
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: rf1
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: rf1
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: rf2
  states: {}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: rf3
  states: {}
- name: virtual_source_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: rf3
  states: {}
- name: virtual_source_0_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: rf2
  states: {}
- name: virtual_source_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: rf1
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: rf0
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: rf2
  states: {}
- name: virtual_source_0_3
  id: virtual_source
  parameters:
    stream_id: rf0
  states: {}
- name: virtual_source_0_3_0
  id: virtual_source
  parameters:
    stream_id: rf3
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: corr_vector
  states: {}

connections:
- [blocks_keep_one_in_n_0, '0', blocks_sub_xx_0, '0']
- [blocks_keep_one_in_n_0, '0', single_pole_iir_filter_xx_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_streams_to_vector_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', blocks_streams_to_vector_0, '1']
- [blocks_multiply_conjugate_cc_0_0_0, '0', blocks_streams_to_vector_0, '2']
- [blocks_multiply_conjugate_cc_0_0_0_0, '0', blocks_streams_to_vector_0, '3']
- [blocks_multiply_conjugate_cc_0_0_0_0_0, '0', blocks_streams_to_vector_0, '4']
- [blocks_multiply_conjugate_cc_0_0_0_0_0_0, '0', blocks_streams_to_vector_0, '5']
- [blocks_streams_to_vector_0, '0', virtual_sink_1, '0']
- [blocks_sub_xx_0, '0', fringe_logger, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [single_pole_iir_filter_xx_1, '0', blocks_sub_xx_0, '1']
- [uhd_usrp_source_0, '0', virtual_sink_0, '0']
- [uhd_usrp_source_0, '1', virtual_sink_0_0, '0']
- [uhd_usrp_source_0, '2', virtual_sink_0_0_0, '0']
- [uhd_usrp_source_0, '3', virtual_sink_0_0_0_0, '0']
- [virtual_source_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [virtual_source_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [virtual_source_0_0_0, '0', blocks_multiply_conjugate_cc_0_0_0_0, '0']
- [virtual_source_0_0_0_0, '0', blocks_multiply_conjugate_cc_0_0_0_0, '1']
- [virtual_source_0_0_0_0_0, '0', blocks_multiply_conjugate_cc_0_0_0_0_0, '1']
- [virtual_source_0_0_0_0_0_0, '0', blocks_multiply_conjugate_cc_0_0_0_0_0_0, '1']
- [virtual_source_0_0_0_0_1, '0', blocks_multiply_conjugate_cc_0_0_0_0_0_0, '0']
- [virtual_source_0_0_0_1, '0', blocks_multiply_conjugate_cc_0_0_0_0_0, '0']
- [virtual_source_0_1, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [virtual_source_0_2, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [virtual_source_0_3, '0', blocks_multiply_conjugate_cc_0_0_0, '0']
- [virtual_source_0_3_0, '0', blocks_multiply_conjugate_cc_0_0_0, '1']
- [virtual_source_1, '0', single_pole_iir_filter_xx_0, '0']

metadata:
  file_format: 1
